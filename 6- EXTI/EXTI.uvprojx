# Keil uVision project EXTI.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXTI
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: GPIO_program.c main.c NVIC_program.c RCC_program.c EXTI_program.c SYSCFG_program.c
  group include
    ./: BIT_MATH.h GPIO_config.h GPIO_interface.h GPIO_private.h NVIC_config.h NVIC_interface.h NVIC_private.h RCC_config.h RCC_interface.h RCC_private.h EXTI_config.h EXTI_interface.h EXTI_private.h SYSCFG_interface.h SYSCFG_private.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
